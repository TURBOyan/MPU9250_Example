# Keil uVision project LPC546XX.uvprojx, settings and files
target SeekFree_LPC546XX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54606J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC546XX
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Drives\common;.\Drives\inc;.\seekfree;.\USER\inc;.\USER\_OLEDMenu;.\USER\_SONIC;.\USER\_PID;.\USER\_BALANCE;.\USER\_CONTROL;.\USER\_ELECTRON;.\USER\_CAMERA;.\USER\_ELECTRON\_MCP41;.\USER\_UI;.\USER\_MECANUM_CTRL;.\USER\_OLED;.\USER\_DATAHELPER;.\USER\MPU9250\MPU9250\MPU_ForUser;.\USER\MPU9250\MPU9250\MPU9250-Lock\driver\eMPL;.\USER\MPU9250\MPU9250\MPU9250-Lock\driver\include;.\USER\MPU9250\MPU9250\MPU9250-Lock\driver\stm32L;.\USER\MPU9250\MPU9250\MPU9250-Lock\eMPL-hal;.\USER\MPU9250\MPU9250\MPU9250-Lock\IIC;.\USER\MPU9250\MPU9250\MPU9250-Lock\mllite;.\USER\MPU9250\MPU9250\MPU9250-Lock\mpl;.\USER\MPU9250\MPU9250\MPU9250-Lock\MPU9250
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group startup
    ./CMSIS/: startup_LPC54606.s system_LPC54606.c system_LPC54606.h
  group drives_h
    ./Drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h
    ./USER/_OLEDMenu/: LPC546XX_eeprom.h
  group drives_c
    ./Drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c
    ./USER/_OLEDMenu/: LPC546XX_eeprom.c
  group common
    ./Drives/common/: assert.c assert.h common.c common.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group user_h
    ./USER/_CONTROL/: SelfBuild_control.h
    ./USER/_PID/: SelfBuild_PID.h
    ./USER/_MECANUM_CTRL/: SelfBuild_Mecanum_Ctrl.h
    ./USER/_OLED/: Selfbuild_oled.h
    ./USER/_OLEDMenu/: SelfBuild_OLEDMenu.h
    ./USER/_BALANCE/_MPU6050/: SelfBuild_myiic.h
    ./USER/_DATAHELPER/: SelfBuild_DataHelper.h
    ./USER/inc/: isr.h LPC546XX_config.h PIN_CFG.h
    ./Drives/inc/: headfile.h
  group user_c
    ./USER/_CONTROL/: SelfBuild_control.c
    ./USER/_PID/: SelfBuild_PID.c
    ./USER/_MECANUM_CTRL/: SelfBuild_Mecanum_Ctrl.c
    ./USER/_OLED/: Selfbuild_oled.c
    ./USER/_OLEDMenu/: SelfBuild_OLEDMenu.c
    ./USER/_DATAHELPER/: SelfBuild_DataHelper.c
    ./USER/src/: isr.c main.c
  group seekfree
    ./seekfree/: SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h VCAN_computer.c VCAN_computer.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h
  group MPU9250
    ./USER/MPU9250/MPU9250/MPU_ForUser/: MPU_ForUser.c MPU_ForUser.h MPU9250_Config.h
    ./USER/MPU9250/MPU9250/MPU9250-Lock/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/driver/stm32L/: log_stm32.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/eMPL-hal/: eMPL_outputs.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/IIC/: mpuiic.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/MPU9250/: mpu9250.c
    ./USER/MPU9250/MPU9250/MPU9250-Lock/mpl/: libmpllib.lib
